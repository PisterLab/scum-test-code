# Keil uVision project freq_sweep_rx_tx.uvprojx, settings and files
target freq_sweep_rx_tx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: freq_sweep_rx_tx +hex
  AfterMake: fromelf --bin .\Objects\freq_sweep_rx_tx.axf -o .\Objects\freq_sweep_rx_tx.bin
  AfterMake: fromelf -cvf .\Objects\freq_sweep_rx_tx.axf -o .\Objects\disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../;..\freq_sweep_rx_tx
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: freq_sweep_rx_tx.c
  group drv
    ../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c zappy2.c zappy2.h temperature.c temperature.h fixed-point.h
