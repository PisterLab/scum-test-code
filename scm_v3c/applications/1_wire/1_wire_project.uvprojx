# Keil uVision project 1_wire_project.uvprojx, settings and files
target oneWire (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 1_wire +hex
  AfterMake: fromelf --bin .\Objects\1_Wire.axf -o .\Objects\1_Wire.bin
  AfterMake: fromelf -cvf .\Objects\1_Wire.axf -o .\Objects\disasm.txt
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: 1_wire_test.c
  group drv
    ../../: cm0dsasm.s memory_map.h retarget.c optical.h optical.c adc.c adc.h uart.c uart.h gpio.c gpio.h rftimer.c rftimer.h scm3c_hw_interface.c scm3c_hw_interface.h radio.c radio.h scum_defs.h 1_wire.c 1_wire.h
    ./: DS18B20.c DS18B20.h
