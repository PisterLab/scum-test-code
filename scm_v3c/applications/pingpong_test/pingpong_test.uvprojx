# Keil uVision project pingpong_test.uvprojx, settings and files
target pingpong_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: pingpong_test
  AfterMake: fromelf --bin pingpong_test.axf -o pingpong_test.bin
  AfterMake: python ..\..\bootload\bootload.py -i pingpong_test.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: pingpong_test.c
  group drv
    ../../: bucket_o_functions.c bucket_o_functions.h cm0dsasm.s Int_Handlers.h Memory_Map.h retarget.c rf_global_vars.h scm3_hardware_interface.c scm3_hardware_interface.h scm3c_hardware_interface.c scm3c_hardware_interface.h scum_radio_bsp.c scum_radio_bsp.h
